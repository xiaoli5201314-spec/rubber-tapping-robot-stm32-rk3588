# Keil uVision project board_web_link_test_f407.uvprojx, settings and files
target board_web_link_test_f407 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(16000000) FPU2 CPUTYPE("Cortex-M4")
  output: board_web_link_test_f407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F407xx
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./: startup_stm32f407xx.s
    ../Src/: system_stm32f4xx.c
  group Web Link and LCD Test
    ../Src/: main.c board.c at_parser.c wifi_test.c lcd_driver.c lcd_display.c
    ../Inc/: test_config.h
