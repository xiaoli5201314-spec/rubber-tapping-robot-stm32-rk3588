# Keil uVision project board_chassis_web_f407_30pct.uvprojx, settings and files
target board_chassis_web_f407_30pct (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(16000000) FPU2 CPUTYPE("Cortex-M4")
  output: board_chassis_web_f407_30pct +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F407xx,WEB_RC_TEST=1,WEB_NO_LCD=1,WEB_MOTOR_TEST=1,WEB_MOTOR_OUTPUT_PERMILLE=300
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\chassis_f407\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./: startup_stm32f407xx.s
    ../Src/: system_stm32f4xx.c
  group Chassis RC and Web - MOTOR OUTPUT ENABLED
    ../Src/: main.c board.c at_parser.c wifi_test.c rc_web_test.c motor_web.c
    ../Inc/: test_config.h
    ../../chassis_f407/App/: rc_capture_core.c safety.c chassis_math.c motor_profile.c
